Commit message: mirs voice updated

File: mirs/src/mirs_description/src/description/mirs_description.urdf (robot description, URDF)
Before this commit: robot mirs, 8 links, 7 joints
Joints:
- joint camera_joint: origin xyz=0 0 0.40 rpy=-${pi/2} 0 0 -> xyz=0 0 0.60 rpy=0 ${pi/2} 0
